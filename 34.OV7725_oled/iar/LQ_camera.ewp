# IAR project LQ_camera.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; LQRELEASE; DEBUG; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pe167, Pa082
  ICCARM.CCIncludePath2: ..; ..\..\..\CMSIS\Include; ..\..\..\Device\board; ..\..\..\Device\drivers\LQRT1052; ..\..\..\Device\drivers\MIMXRT1052; ..\..\..\Device\drivers\MIMXRT1052\camera; ..\..\..\Doc; ..\..\..\Device\startup\iar; ..\..\..\Device\utilities; ..\..\..\Device\xip; ..\..\..\Device
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: LQ_LED.srec
  ILINK.IlinkOutputFile: LQ_LED.out
  ILINK.IlinkConfigDefines: __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: LQ_RT1052QSPI_Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../../../Device/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../Device/drivers/MIMXRT1052/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_enc.c fsl_enc.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_pit.c fsl_pit.h fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h fsl_xbara.c fsl_xbara.h pitimer.c pitimer.h speedProcess.c speedProcess.h sys.h
    ../../../Device/drivers/MIMXRT1052/camera/: fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h fsl_sccb.c fsl_sccb.h fsl_video_common.h
  group lq
    ../../../Device/drivers/MIMXRT1052/: adcprocess.c adcprocess.h angleProcess.c angleProcess.h ControlElement.c ControlElement.h imageGetSaveAndSend.c imageGetSaveAndSend.h MainControl.c MainControl.h myUtil.c myUtil.h ring.c ring.h szx_color.c szx_color.h szx_image.c szx_image.h uiAdcPage.c uiCamPage.c UIControl.c UIControl.h uiMainConPage.c uiMainPage.c uiRunPage.c uiSpeedPage.c UIVar.c UIVar.h
    ../../../Device/drivers/LQRT1052/: ANO_DT.c ANO_DT.h LQ_12864.h LQ_12864SPI.c LQ_ADC.c LQ_ADC.h LQ_Camera.c LQ_Camera.h LQ_CCD.c LQ_CCD.h LQ_CSI.c LQ_CSI.h LQ_Encoder.c LQ_Encoder.h LQ_FLASH.c LQ_FLASH.h LQ_GPIO.c LQ_GPIO.h LQ_GPIO_Cfg.h LQ_IIC.c LQ_IIC.h LQ_KEY.c LQ_KEY.h LQ_LED.c LQ_LED.h LQ_MT9V034M.c LQ_MT9V034M.h LQ_OV7725M.c LQ_OV7725M.h LQ_PIT.c LQ_PIT.h LQ_PWM.c LQ_PWM.h LQ_QTMR.c LQ_QTMR.h LQ_SGP18T.c LQ_SGP18T.h LQ_SPI.c LQ_SPI.h LQ_SYSTICK.c LQ_SYSTICK.h LQ_UART.c LQ_UART.h LQ_W25Q128.c LQ_W25Q128.h
  group source
    ../: include.h irq.c main.c
    ../../../Device/drivers/MIMXRT1052/: main.h
  group startup
    ../../../Device/startup/iar/: startup_MIMXRT1052.s
    ../../../Device/: system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../Device/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h lpuart_adapter.c serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h uart.h
  group xip
    ../../../Device/xip/: external_flash_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h xip_config.c
