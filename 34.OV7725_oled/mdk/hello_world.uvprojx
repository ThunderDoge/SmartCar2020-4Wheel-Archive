# Keil uVision project hello_world.uvprojx, settings and files
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.11.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=1296,186
  c include: ..\..\34.OV7725_display_oled;..\..\..\CMSIS\Include;..\..\..\Device\board;..\..\..\Device\drivers\LQRT1052;..\..\..\Device\drivers\MIMXRT1052;..\..\..\Device\drivers\MIMXRT1052\camera;..\..\..\Device\startup\iar;..\..\..\Device\utilities;..\..\..\Device\xip;..\..\..\Device
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: main.c irq.c
  group board
    ../../../Device/board/: board.c clock_config.c pin_mux.c
  group lq
    ../../../Device/drivers/LQRT1052/: LQ_LED.c LQ_KEY.c LQ_SGP18T.c LQ_12864SPI.c LQ_UART.c LQ_IIC.c LQ_Camera.c LQ_CSI.c LQ_MT9V034M.c LQ_OV7725M.c
  group drivers
    ../../../Device/drivers/MIMXRT1052/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c fsl_lpi2c.c fsl_csi.c
    ../../../Device/drivers/MIMXRT1052/camera/: fsl_csi_camera_adapter.c fsl_sccb.c
  group startup
    ../../../Device/startup/arm/: startup_MIMXRT1052.s
    ../../../Device/: system_MIMXRT1052.c
  group utilities
    ../../../Device/utilities/: fsl_assert.c fsl_debug_console.c fsl_str.c lpuart_adapter.c serial_manager.c serial_port_uart.c
  group xip
    ../../../Device/xip/: fsl_flexspi_nor_boot.c xip_config.c
  group doc
    ../: readme.txt
